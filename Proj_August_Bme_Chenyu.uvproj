# Keil uVision project Proj_August_Bme_Chenyu.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Proj_August_Bme_Chenyu +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c LCD1602.c MLX90614.c
  group header files
    ./: delay.h LCD1602.h main.h MLX90614.h
